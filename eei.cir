** edCollab **
*
* NI Multisim to SPICE Netlist Export
* Generated by: Matt
* Tue, Oct 30, 2012 16:23:55
*

*## Multisim Component C1 ##*
cC1 SC14/IO2 SC12/IO1 2e-010

*## Multisim Component R1 ##*
rR1 SC14/IO2 SC12/IO1 100000000 vresR1
.model vresR1 r(  )

*## Multisim Component IdealOpAmp ##*
* SHOW_TEMPLATE_DATA_ONLY
BIdealOpAmp Recording 0 v = { 1 * v(SC1/IO2) }

*## Multisim Component R14 ##*
rR14 SC1/IO2 0 1e14 vresR14
.model vresR14 r(  )

*## Multisim Component C2 ##*
cC2 SC1/IO2 0 4e-012

*## Multisim Component Radhesive_seal10 ##*
rRadhesive_seal10 SC11/IO1 SC12/IO1 0.00375 vresRadhesive_seal10
.model vresRadhesive_seal10 r(  )

*## Multisim Component Radhesive_seal9 ##*
rRadhesive_seal9 SC11/IO1 SC11/IO1 0.00375 vresRadhesive_seal9
.model vresRadhesive_seal9 r(  )

*## Multisim Component Radhesive_seal8 ##*
rRadhesive_seal8 SC11/IO1 SC11/IO1 0.00375 vresRadhesive_seal8
.model vresRadhesive_seal8 r(  )

*## Multisim Component Radhesive_seal7 ##*
rRadhesive_seal7 SC11/IO1 SC11/IO1 0.00375 vresRadhesive_seal7
.model vresRadhesive_seal7 r(  )

*## Multisim Component Radhesive_seal6 ##*
rRadhesive_seal6 SC11/IO1 SC11/IO1 0.00375 vresRadhesive_seal6
.model vresRadhesive_seal6 r(  )

*## Multisim Component Radhesive_seal5 ##*
rRadhesive_seal5 SC11/IO1 SC11/IO1 0.00375 vresRadhesive_seal5
.model vresRadhesive_seal5 r(  )

*## Multisim Component Radhesive_seal4 ##*
rRadhesive_seal4 SC11/IO1 SC11/IO1 0.00375 vresRadhesive_seal4
.model vresRadhesive_seal4 r(  )

*## Multisim Component Radhesive_seal3 ##*
rRadhesive_seal3 SC11/IO1 SC11/IO1 0.00375 vresRadhesive_seal3
.model vresRadhesive_seal3 r(  )

*## Multisim Component Radhesive_seal2 ##*
rRadhesive_seal2 SC11/IO1 SC11/IO1 0.00375 vresRadhesive_seal2
.model vresRadhesive_seal2 r(  )

*## Multisim Component Radhesive_seal1 ##*
rRadhesive_seal1 SC11/IO1 SC11/IO1 0.00375 vresRadhesive_seal1
.model vresRadhesive_seal1 r(  )

*## Multisim Component Rpenetration_seal ##*
rRpenetration_seal SC14/IO2 SC11/IO1 4e9 vresRpenetration_seal
.model vresRpenetration_seal r(  )

*## Multisim Component Rbath ##*
rRbath SC12/IO1 0 100 vresRbath
.model vresRbath r(  )

*## Multisim Component ActionPotential ##*
vActionPotential SC14/IO2 SC12/IO1 dc -0.053288677
+
+
+ pwl(0 -0.053288677 2e-005 -0.053058393 4e-005 -0.052948116 6e-005 -0.0528573 8e-005 -0.052785944 0.0001 -0.052691884 0.00012 -0.052558903 0.00014 -0.052442139 0.00016 -0.052406461 0.00018 -0.052338349 0.0002 -0.052276724 0.00022 -0.052156717 0.00024 -0.051984814 0.00026 -0.051900485 0.00028 -0.051845346 0.0003 -0.051770747 0.00032 -0.051676687 0.00034 -0.051579384 0.00036 -0.051524246 0.00038 -0.051430186 0.0004 -0.051371804 0.00042 -0.051248553 0.00044 -0.051099355 0.00046 -0.050982591 0.00048 -0.050914479 0.0005 -0.050859341 0.00052 -0.050775011 0.00054 -0.050629057 0.00056 -0.050512293 0.00058 -0.050502563 0.0006 -0.050457154 0.00062 -0.05033066 0.00064 -0.050262548 0.00066 -0.050165245 0.00068 -0.050129567 0.0007 -0.050106863 0.00072 -0.05001929 0.00074 -0.049827927 0.00076 -0.04979225 0.00078 -0.049704677 0.0008 -0.049630078 0.00082 -0.049542505 0.00084 -0.049471149 0.00086 -0.049373846 0.00088 -0.049331681 0.0009 -0.049296004 0.00092 -0.049166266 0.00094 -0.049039772 0.00096 -0.04899112 0.00098 -0.048893817 0.001 -0.048809488 0.00102 -0.048728402 0.00104 -0.048595421 0.00106 -0.048595421 0.00108 -0.048553256 0.0011 -0.048511092 0.00112 -0.048381354 0.00114 -0.048264591 0.00116 -0.048186748 0.00118 -0.048144583 0.0012 -0.048034307 0.00122 -0.047953221 0.00124 -0.047865648 0.00126 -0.047907813 0.00128 -0.0478397 0.0013 -0.047807266 0.00132 -0.04762239 0.00134 -0.047564008 0.00136 -0.047476436 0.00138 -0.047437514 0.0014 -0.047346698 0.00142 -0.047220204 0.00144 -0.047174796 0.00146 -0.047223448 0.00148 -0.047126145 0.0015 -0.047006137 0.00152 -0.046860183 0.00154 -0.046863426 0.00156 -0.046785584 0.00158 -0.046723959 0.0016 -0.04656503 0.00162 -0.046519622 0.00164 -0.046464484 0.00166 -0.046513135 0.00168 -0.046445023 0.0017 -0.046360694 0.00172 -0.046188792 0.00174 -0.046175818 0.00176 -0.046085002 0.00178 -0.046020133 0.0018 -0.045893639 0.00182 -0.045838501 0.00184 -0.045812553 0.00186 -0.045767145 0.00188 -0.045673086 0.0019 -0.045624434 0.00192 -0.045559565 0.00194 -0.04549794 0.00196 -0.045416854 0.00198 -0.045313064 0.002 -0.045231979 0.00202 -0.045212518 0.00204 -0.045118458 0.00206 -0.045001695 0.00208 -0.044930339 0.0021 -0.044901148 0.00212 -0.04484601 0.00214 -0.044771411 0.00216 -0.044729246 0.00218 -0.044657891 0.0022 -0.044622213 0.00222 -0.044560588 0.00224 -0.044460041 0.00226 -0.044356251 0.00228 -0.044340034 0.0023 -0.044301113 0.00232 -0.044210297 0.00234 -0.044096777 0.00236 -0.044061099 0.00238 -0.044041638 0.0024 -0.043950822 0.00242 -0.043837302 0.00244 -0.043736756 0.00246 -0.043684861 0.00248 -0.043616749 0.0025 -0.043577828 0.00252 -0.043477281 0.00254 -0.043383222 0.00256 -0.043379978 0.00258 -0.043370248 0.0026 -0.043253484 0.00262 -0.043201589 0.00264 -0.043084826 0.00266 -0.043055635 0.00268 -0.042981036 0.0027 -0.04289022 0.00272 -0.042789673 0.00274 -0.042779943 0.00276 -0.042711831 0.00278 -0.04269237 0.0028 -0.042588581 0.00282 -0.042491278 0.00284 -0.042413435 0.00286 -0.042358297 0.00288 -0.042270724 0.0029 -0.04214423 0.00292 -0.042085849 0.00294 -0.042076118 0.00296 -0.04202098 0.00298 -0.041972329 0.003 -0.041871782 0.00302 -0.041826374 0.00304 -0.041761506 0.00306 -0.041667446 0.00308 -0.041540952 0.0031 -0.041521492 0.00312 -0.041492301 0.00314 -0.041469597 0.00316 -0.041362564 0.00318 -0.041291208 0.0032 -0.041268504 0.00322 -0.041271747 0.00324 -0.041174445 0.00326 -0.041022003 0.00328 -0.040872805 0.0033 -0.040908483 0.00332 -0.040869562 0.00334 -0.040717121 0.00336 -0.04069766 0.00338 -0.040649009 0.0034 -0.040603601 0.00342 -0.040558193 0.00344 -0.040405751 0.00346 -0.04036683 0.00348 -0.040321422 0.0035 -0.040269527 0.00352 -0.04013006 0.00354 -0.040123573 0.00356 -0.040087895 0.00358 -0.04002627 0.0036 -0.039964645 0.00362 -0.039857612 0.00364 -0.039786256 0.00366 -0.039776526 0.00368 -0.039672736 0.0037 -0.039575433 0.00372 -0.039546242 0.00374 -0.039504078 0.00376 -0.039455426 0.00378 -0.039312716 0.0038 -0.039176491 0.00382 -0.039092162 0.00384 -0.039111623 0.00386 -0.039101893 0.00388 -0.038975399 0.0039 -0.038852149 0.00392 -0.038861879 0.00394 -0.038822958 0.00396 -0.038780793 0.00398 -0.038618622 0.004 -0.03855051 0.00402 -0.038527806 0.00404 -0.038498615 0.00406 -0.038391582 0.00408 -0.038278062 0.0041 -0.038255358 0.00412 -0.038235897 0.00414 -0.038167785 0.00416 -0.038067239 0.00418 -0.037943988 0.0042 -0.037934258 0.00422 -0.037862903 0.00424 -0.037762356 0.00426 -0.037639106 0.00428 -0.037590455 0.0043 -0.037616402 0.00432 -0.037567751 0.00434 -0.037382875 0.00436 -0.037353684 0.00438 -0.037288816 0.0044 -0.037214217 0.00442 -0.037116914 0.00444 -0.036983934 0.00446 -0.036964473 0.00448 -0.036967716 0.0045 -0.036928795 0.00452 -0.036776354 0.00454 -0.036656347 0.00456 -0.036614183 0.00458 -0.036555801 0.0046 -0.03641309 0.00462 -0.03628011 0.00464 -0.036202268 0.00466 -0.03618605 0.00468 -0.036143886 0.0047 -0.036030366 0.00472 -0.035933063 0.00474 -0.035832517 0.00476 -0.035754675 0.00478 -0.035644398 0.0048 -0.035527635 0.00482 -0.035365463 0.00484 -0.035303838 0.00486 -0.035200048 0.00488 -0.035112476 0.0049 -0.034956791 0.00492 -0.034830298 0.00494 -0.034655153 0.00496 -0.034486495 0.00498 -0.034188099 0.005 -0.03396106 0.00502 -0.033552388 0.00504 -0.033017223 0.00506 -0.032336103 0.00508 -0.031638767 0.0051 -0.030678713 0.00512 -0.029686225 0.00514 -0.028369396 0.00516 -0.027127165 0.00518 -0.025690329 0.0052 -0.024198355 0.00522 -0.022485828 0.00524 -0.020630592 0.00526 -0.018545073 0.00528 -0.016349279 0.0053 -0.013926445 0.00532 -0.011127376 0.00534 -0.00794234 0.00536 -0.004484858 0.00538 -0.000615462 0.0054 0.003455026 0.00542 0.007752553 0.00544 0.012040352 0.00546 0.01626977 0.00548 0.020353236 0.0055 0.024232368 0.00552 0.027835812 0.00554 0.031192757 0.00556 0.034254553 0.00558 0.037147692 0.0056 0.039800819 0.00562 0.042165281 0.00564 0.044309192 0.00566 0.046313636 0.00568 0.048097527 0.0057 0.049790603 0.00572 0.051198257 0.00574 0.052495634 0.00576 0.05356597 0.00578 0.054642794 0.0058 0.055463386 0.00582 0.056189918 0.00584 0.056764008 0.00586 0.057279717 0.00588 0.057759747 0.0059 0.058217073 0.00592 0.058366272 0.00594 0.058444115 0.00596 0.05848628 0.00598 0.058528445 0.006 0.058466819 0.00602 0.058301403 0.00604 0.058058144 0.00606 0.05784732 0.00608 0.057646226 0.0061 0.057341342 0.00612 0.05690672 0.00614 0.056429933 0.00616 0.056011528 0.00618 0.055537985 0.0062 0.054963895 0.00622 0.054266554 0.00624 0.053685978 0.00626 0.053183244 0.00628 0.052563746 0.0063 0.051892353 0.00632 0.05111717 0.00634 0.050397126 0.00636 0.049722491 0.00638 0.049057585 0.0064 0.048198074 0.00642 0.047422892 0.00644 0.046599058 0.00646 0.045882259 0.00648 0.045133025 0.0065 0.044341626 0.00652 0.043459412 0.00654 0.042716665 0.00656 0.041944728 0.00658 0.041185764 0.0066 0.040404097 0.00662 0.039580265 0.00664 0.038717512 0.00666 0.038000714 0.00668 0.037196343 0.0067 0.036382242 0.00672 0.035522733 0.00674 0.034741067 0.00676 0.034024269 0.00678 0.033284768 0.0068 0.032490128 0.00682 0.031672784 0.00684 0.030861928 0.00686 0.030128913 0.00688 0.029418603 0.0069 0.028649911 0.00692 0.027783917 0.00694 0.027024956 0.00696 0.026259508 0.00698 0.025620553 0.007 0.024861592 0.00702 0.024066954 0.00704 0.023327453 0.00706 0.022623631 0.00708 0.021948999 0.0071 0.021261394 0.00712 0.020427834 0.00714 0.019633196 0.00716 0.018958565 0.00718 0.018296907 0.0072 0.017648223 0.00722 0.016898993 0.00724 0.016127059 0.00726 0.015413507 0.00728 0.014758336 0.0073 0.014096679 0.00732 0.013373396 0.00734 0.012624167 0.00736 0.01185872 0.00738 0.011216523 0.0074 0.01056784 0.00742 0.009886722 0.00744 0.009147223 0.00746 0.008472592 0.00748 0.007755797 0.0075 0.007146034 0.00752 0.006422752 0.00754 0.00569947 0.00756 0.004982675 0.00758 0.004327505 0.0076 0.003685308 0.00762 0.00299446 0.00764 0.002261448 0.00766 0.00155114 0.00768 0.000863536 0.0077 0.00011755 0.00772 -0.000592758 0.00774 -0.001293336 0.00776 -0.002097704 0.00778 -0.002785308 0.0078 -0.003463182 0.00782 -0.004108622 0.00784 -0.004841634 0.00786 -0.00558762 0.00788 -0.006330362 0.0079 -0.007063374 0.00792 -0.007728275 0.00794 -0.008438583 0.00796 -0.009242951 0.00798 -0.009930555 0.008 -0.010618159 0.00802 -0.011321981 0.00804 -0.011996612 0.00806 -0.012693947 0.00808 -0.013517775 0.0081 -0.014231327 0.00812 -0.014925418 0.00814 -0.015616266 0.00816 -0.016365496 0.00818 -0.017108239 0.0082 -0.01780233 0.00822 -0.018577508 0.00824 -0.019216461 0.00826 -0.019865145 0.00828 -0.020688974 0.0083 -0.021340901 0.00832 -0.022057697 0.00834 -0.022719355 0.00836 -0.023355065 0.00838 -0.024006993 0.0084 -0.024736763 0.00842 -0.025375717 0.00844 -0.025982237 0.00846 -0.026553079 0.00848 -0.027237441 0.0085 -0.027843961 0.00852 -0.028437507 0.00854 -0.028975916 0.00856 -0.029537028 0.00858 -0.030130575 0.0086 -0.030737095 0.00862 -0.031324155 0.00864 -0.031836616 0.00866 -0.032368538 0.00868 -0.032822617 0.0087 -0.033283184 0.00872 -0.033772941 0.00874 -0.034230264 0.00876 -0.034648666 0.00878 -0.035050851 0.0088 -0.035534121 0.00882 -0.035994688 0.00884 -0.036435794 0.00886 -0.036789328 0.00888 -0.037097454 0.0089 -0.037418553 0.00892 -0.037836955 0.00894 -0.038158055 0.00896 -0.038449963 0.00898 -0.038677003 0.009 -0.039033781 0.00902 -0.039367854 0.00904 -0.039744092 0.00906 -0.040048974 0.00908 -0.040178711 0.0091 -0.040421969 0.00912 -0.04069766 0.00914 -0.040931187 0.00916 -0.041213366 0.00918 -0.041375537 0.0092 -0.041605821 0.00922 -0.041884756 0.00924 -0.04212477 0.00926 -0.042325863 0.00928 -0.042471817 0.0093 -0.042611285 0.00932 -0.042818864 0.00934 -0.043006983 0.00936 -0.043172398 0.00938 -0.043295649 0.0094 -0.043396195 0.00942 -0.043587558 0.00944 -0.04377892 0.00946 -0.043915145 0.00948 -0.044035152 0.0095 -0.044116237 0.00952 -0.044233001 0.00954 -0.044417877 0.00956 -0.04452491 0.00958 -0.044644917 0.0096 -0.044781141 0.00962 -0.044884931 0.00964 -0.045008182 0.00966 -0.045069807 0.00968 -0.045154136 0.0097 -0.0452709 0.00972 -0.045416854 0.00974 -0.045504427 0.00976 -0.045484966 0.00978 -0.045553079 0.0098 -0.045718494 0.00982 -0.045754171 0.00984 -0.045802823 0.00986 -0.045815797 0.00988 -0.045893639 0.0099 -0.045964995 0.00992 -0.046075272 0.00994 -0.046075272 0.00996 -0.046091489 0.00998 -0.046182305 0.01 -0.046263391 0.01002 -0.046305555 0.01004 -0.046295825 0.01006 -0.046269878 0.01008 -0.046331503 0.0101 -0.046432049 0.01012 -0.046487188 0.01014 -0.046535839 0.01016 -0.046500161 0.01018 -0.046561787 0.0102 -0.046603951 0.01022 -0.046597465 0.01024 -0.04664936 0.01026 -0.046616925 0.01028 -0.046616925 0.0103 -0.04664936 0.01032 -0.046717472 0.01034 -0.046694768 0.01036 -0.046736932 0.01038 -0.046730445 0.0104 -0.046698011 0.01042 -0.046749906 0.01044 -0.046766123 0.01046 -0.04676288 0.01048 -0.046740176 0.0105 -0.046753149 0.01052 -0.046801801 0.01054 -0.0468764 0.01056 -0.046882887 0.01058 -0.0468764 0.0106 -0.046827748 0.01062 -0.046824505 0.01064 -0.046814775 0.01066 -0.046811531 0.01068 -0.046795314 0.0107 -0.046779097 0.01072 -0.046821262 0.01074 -0.046873157 0.01076 -0.046895861 0.01078 -0.046869913 0.0108 -0.046830992 0.01082 -0.04677261 0.01084 -0.046785584 0.01086 -0.04678234 0.01088 -0.046805044 0.0109 -0.046727202 0.01092 -0.046746663 0.01094 -0.046730445 0.01096 -0.046785584 0.01098 -0.046756393 0.011 -0.046691524 0.01102 -0.04667855 0.01104 -0.046681794 0.01106 -0.046691524 0.01108 -0.046685037 0.0111 -0.046597465 0.01112 -0.046616925 0.01114 -0.046639629 0.01116 -0.04665909 0.01118 -0.04666882 0.0112 -0.046607195 0.01122 -0.046597465 0.01124 -0.04657476 0.01126 -0.046584491 0.01128 -0.046568274 0.0113 -0.046470971 0.01132 -0.046464484 0.01134 -0.046467727 0.01136 -0.046467727 0.01138 -0.046435293 0.0114 -0.046354207 0.01142 -0.046373668 0.01144 -0.046380154 0.01146 -0.04635745 0.01148 -0.046373668 0.0115 -0.046292582 0.01152 -0.046308799 0.01154 -0.046247174 0.01156 -0.04624393 0.01158 -0.046208252 0.0116 -0.046185548 0.01162 -0.046211496 0.01164 -0.046179061 0.01166 -0.046162844 0.01168 -0.046146627 0.0117 -0.046068785 0.01172 -0.046075272 0.01174 -0.046052567 0.01176 -0.046059054 0.01178 -0.045945534 0.0118 -0.045883909 0.01182 -0.045900126 0.01184 -0.045942291 0.01186 -0.045909856 0.01188 -0.045948778 0.0119 -0.045890396 0.01192 -0.045854718 0.01194 -0.045815797 0.01196 -0.045789849 0.01198 -0.045724981 0.012 -0.045731467 0.01202 -0.045708763 0.01204 -0.045741198 0.01206 -0.045699033 0.01208 -0.045712007 0.0121 -0.045630921 0.01212 -0.045582269 0.01214 -0.045588756 0.01216 -0.045546592 0.01218 -0.045468749 0.0122 -0.045420098 0.01222 -0.045397394 0.01224 -0.045387663 0.01226 -0.045442802 0.01228 -0.045377933 0.0123 -0.045329282 0.01232 -0.04528063 0.01234 -0.045283874 0.01236 -0.045261169 0.01238 -0.045193057 0.0124 -0.045105485 0.01242 -0.045095754 0.01244 -0.045105485 0.01246 -0.045124945 0.01248 -0.045069807 0.0125 -0.045066563 0.01252 -0.044962774 0.01254 -0.045011425 0.01256 -0.044956287 0.01258 -0.044923852 0.0126 -0.044826549 0.01262 -0.044842766 0.01264 -0.044865471 0.01266 -0.044839523 0.01268 -0.044761681 0.0127 -0.044703299 0.01272 -0.044696812 0.01274 -0.04475195 0.01276 -0.044670865 0.01278 -0.044625456 0.0128 -0.044580048 0.01282 -0.044573561 0.01284 -0.044631943 0.01286 -0.044560588 0.01288 -0.044473015 0.0129 -0.044476258 0.01292 -0.044437337 0.01294 -0.044460041 0.01296 -0.044440581 0.01298 -0.044353008 0.013 -0.044320574 0.01302 -0.044301113 0.01304 -0.044278409 0.01306 -0.044275166 0.01308 -0.044187593 0.0131 -0.044116237 0.01312 -0.044129211 0.01314 -0.044112994 0.01316 -0.044122724 0.01318 -0.044103264 0.0132 -0.044025421 0.01322 -0.043989743 0.01324 -0.0439865 0.01326 -0.043941092 0.01328 -0.043895684 0.0133 -0.04387298 0.01332 -0.043853519 0.01334 -0.043892441 0.01336 -0.043876223 0.01338 -0.043834059 0.0134 -0.043804868 0.01342 -0.043814598 0.01344 -0.043775677 0.01346 -0.043723782 0.01348 -0.043691348 0.0135 -0.043629722 0.01352 -0.043584314 0.01354 -0.043590801 0.01356 -0.043581071 0.01358 -0.043587558 0.0136 -0.043506472 0.01362 -0.043477281 0.01364 -0.043409169 0.01366 -0.043431873)

** IntracellularElectrode SC1 **

*## Multisim Component R2 ##*
rR2 SC14/IO2 SC1/IO2 0.00375 vresR2
.model vresR2 r(  )

** InCellElectrode SC2 **

*## Multisim Component R3 ##*
rR3 SC11/IO1 SC1/IO2 0.00375 vresR3
.model vresR3 r(  )

** InCellElectrode SC3 **

*## Multisim Component R4 ##*
rR4 SC11/IO1 SC1/IO2 0.00375 vresR4
.model vresR4 r(  )

** InCellElectrode SC4 **

*## Multisim Component R5 ##*
rR5 SC11/IO1 SC1/IO2 0.00375 vresR5
.model vresR5 r(  )

** InCellElectrode SC5 **

*## Multisim Component R6 ##*
rR6 SC11/IO1 SC1/IO2 0.00375 vresR6
.model vresR6 r(  )

** InCellElectrode SC6 **

*## Multisim Component R7 ##*
rR7 SC11/IO1 SC1/IO2 0.00375 vresR7
.model vresR7 r(  )

** InCellElectrode SC7 **

*## Multisim Component R8 ##*
rR8 SC11/IO1 SC1/IO2 0.00375 vresR8
.model vresR8 r(  )

** InCellElectrode SC8 **

*## Multisim Component R9 ##*
rR9 SC11/IO1 SC1/IO2 0.00375 vresR9
.model vresR9 r(  )

** InCellElectrode SC9 **

*## Multisim Component R10 ##*
rR10 SC11/IO1 SC1/IO2 0.00375 vresR10
.model vresR10 r(  )

** InCellElectrode SC10 **

*## Multisim Component R11 ##*
rR11 SC11/IO1 SC1/IO2 0.00375 vresR11
.model vresR11 r(  )

** InCellElectrode SC11 **

*## Multisim Component R12 ##*
rR12 SC11/IO1 SC1/IO2 0.00375 vresR12
.model vresR12 r(  )

** ExtracellularElectrode SC12 **

*## Multisim Component R13 ##*
rR13 SC12/IO1 SC1/IO2 0.00375 vresR13
.model vresR13 r(  )

** MembraneSection SC13 **

*## Multisim Component C3 ##*
cC3 SC11/IO1 SC14/IO2 2e-015

*## Multisim Component R15 ##*
rR15 SC11/IO1 SC14/IO2 1e+013 vresR15
.model vresR15 r(  )

** MembraneSection SC14 **

*## Multisim Component C4 ##*
cC4 SC11/IO1 SC14/IO2 2e-015

*## Multisim Component R16 ##*
rR16 SC11/IO1 SC14/IO2 1e+013 vresR16
.model vresR16 r(  )

** MembraneSection SC15 **

*## Multisim Component C5 ##*
cC5 SC11/IO1 SC14/IO2 2e-015

*## Multisim Component R17 ##*
rR17 SC11/IO1 SC14/IO2 1e+013 vresR17
.model vresR17 r(  )

** MembraneSection SC16 **

*## Multisim Component C6 ##*
cC6 SC11/IO1 SC14/IO2 2e-015

*## Multisim Component R18 ##*
rR18 SC11/IO1 SC14/IO2 1e+013 vresR18
.model vresR18 r(  )

** MembraneSection SC17 **

*## Multisim Component C7 ##*
cC7 SC11/IO1 SC14/IO2 2e-015

*## Multisim Component R19 ##*
rR19 SC11/IO1 SC14/IO2 1e+013 vresR19
.model vresR19 r(  )

** MembraneSection SC18 **

*## Multisim Component C8 ##*
cC8 SC11/IO1 SC14/IO2 2e-015

*## Multisim Component R20 ##*
rR20 SC11/IO1 SC14/IO2 1e+013 vresR20
.model vresR20 r(  )

** MembraneSection SC19 **

*## Multisim Component C9 ##*
cC9 SC11/IO1 SC14/IO2 2e-015

*## Multisim Component R21 ##*
rR21 SC11/IO1 SC14/IO2 1e+013 vresR21
.model vresR21 r(  )

** MembraneSection SC20 **

*## Multisim Component C10 ##*
cC10 SC11/IO1 SC14/IO2 2e-015

*## Multisim Component R22 ##*
rR22 SC11/IO1 SC14/IO2 1e+013 vresR22
.model vresR22 r(  )

** MembraneSection SC21 **

*## Multisim Component C11 ##*
cC11 SC11/IO1 SC14/IO2 2e-015

*## Multisim Component R23 ##*
rR23 SC11/IO1 SC14/IO2 1e+013 vresR23
.model vresR23 r(  )
