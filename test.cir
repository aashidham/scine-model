test circuit
.include cpe.cir
v1 0 1 ac 1
x1 1 2 cpe
v2 2 3 0v
r1 3 0 1
